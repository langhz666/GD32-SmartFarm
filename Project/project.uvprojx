# Keil uVision project project.uvprojx, settings and files
target GD32F103C8T6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F103C8 GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\GD\GD32F10x\Include;..\Libraries\GD32F10x_standard_peripheral\Include;..\User;..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c delay.c
  group BSP
    ../User/: gd32f10x_it.c systick.c
  group Core
    ../Libraries/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ../../GD32F10x_Firmware_Library_V2.2.1/Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
  group Libriry
    ../Libraries/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Driver
    ../Driver/driver_oled/: OLED_Data.c driver_oled.c
    ../Driver/driver_usart/: driver_usart.c
    ../Driver/driver_i2c/: driver_i2c.c
    ../Driver/driver_encoder/: driver_encoder.c
    ../Driver/driver_light/: driver_light.c iic_light.c
    ../Driver/driver_bluetooth/: driver_bluetooth.c
    ../Driver/driver_led/: driver_led.c
    ../Driver/driver_timer/: driver_timer.c
    ../Driver/driver_soil/: driver_soil.c
    ../Driver/driver_rain/: driver_rain.c
    ../Driver/driver_adc/: driver_adc.c
